# Repository turcoale/Bancas2.0

## KiCad design diseñopcb/cape/beaglebonecape.kicad_pcb

Parts:
C1, C2, C3, C4: 1 uF
C5: 0.1 uF
C6, C7, C8, C9, C10, C11, C12, C13: C
CON1: B_POS
CON2: B_PP
CON3: B_NEG
CON4: BT
CON5: LED_POS
CON6: LED_NEG
CON7: LED_PP
CON8: LCD16X2; WC1602A
CON9: MIC
CON10: UART1
CON11: UART2
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: 1N4148
D11: 1N4001
P1, P2: CONN_1
Q1, Q2, Q3: BC548; TO92
R1, R6, R11: 560
R4, R5, R9, R10, R13, R15: 100k
R14: 10k
RL1: RM50-XX21
U2: MAX3232

Connections:
/Beaglebone Black/DC_3.3V: C8.1, C13.1, CON10.4, D1.2 (K), D3.2 (K), D5.2 (K), D7.2 (K), D9.2 (K), R4.1, R5.1, R9.1, R10.1, R13.1, U2.16 (VCC); also elsewhere on the board
/Beaglebone Black/GPIO1_0: C2.1, CON2.2 (PM), D3.1 (A), D4.2 (K), R5.2; also elsewhere on the board
/Beaglebone Black/GPIO1_1: R11.1; also elsewhere on the board
/Beaglebone Black/GPIO1_2: C5.1, D9.1 (A), D10.2 (K), R13.2, RL1.C; also elsewhere on the board
/Beaglebone Black/GPIO1_4: C3.1, CON3.2 (PM), D5.1 (A), D6.2 (K), R9.2; also elsewhere on the board
/Beaglebone Black/GPIO1_5: R1.1; also elsewhere on the board
/Beaglebone Black/GPIO1_6: C4.1, CON4.2 (PM), D7.1 (A), D8.2 (K), R10.2; also elsewhere on the board
/Beaglebone Black/GPIO1_30: C1.1, CON1.2 (PM), D1.1 (A), D2.2 (K), R4.2; also elsewhere on the board
/Beaglebone Black/GPIO1_31: R6.1; also elsewhere on the board
/Beaglebone Black/GPIO2_6: CON8.11 (D4); also elsewhere on the board
/Beaglebone Black/GPIO2_7: CON8.12 (D5); also elsewhere on the board
/Beaglebone Black/GPIO2_8: CON8.13 (D6); also elsewhere on the board
/Beaglebone Black/GPIO2_9: CON8.14 (D7); also elsewhere on the board
/Beaglebone Black/GPIO2_10: CON8.6 (E); also elsewhere on the board
/Beaglebone Black/GPIO2_11: CON8.5 (R/W); also elsewhere on the board
/Beaglebone Black/GPIO2_12: CON8.4 (RS); also elsewhere on the board
/Beaglebone Black/UART1_RXD: CON10.2; also elsewhere on the board
/Beaglebone Black/UART1_TXD: CON10.1; also elsewhere on the board
/Beaglebone Black/UART2_RXD: U2.12 (R1OUT); also elsewhere on the board
/Beaglebone Black/UART2_TXD: U2.11 (T1IN); also elsewhere on the board
/Beaglebone Black/VDD_5V: C6.1, CON5.1, CON6.1, CON7.1, CON8.2 (VDD), CON8.15 (LED+); also elsewhere on the board
/Tierra: P1.1, P2.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C11.1, C12.2, C13.2, CON1.1, CON2.1, CON3.1, CON4.1, CON8.1 (VSS), CON8.3 (VO), CON8.17, CON8.18, CON8.19, CON8.20, CON8.21, CON8.22, CON8.23, CON8.24, CON8.25, CON8.26, CON8.27, CON8.28, CON8.29, CON8.30, CON8.31, CON8.32, CON8.33, CON8.34, CON10.3, CON11.1, CON11.3, D2.1 (A), D4.1 (A), D6.1 (A), D8.1 (A), D10.1 (A), Q1.3 (E), Q2.3 (E), Q3.3 (E), R15.2, RL1.NO, U2.15 (GND); also elsewhere on the board
unnamed: C10.1, U2.4 (C2+)
unnamed: C9.2, U2.3 (C1-)
unnamed: C9.1, U2.1 (C1+)
unnamed: C7.1, CON9.1, D11.1 (A), RL1.1
unnamed: CON9.2 (PM), D11.2 (K), R14.1, RL1.2
unnamed: C10.2, U2.5 (C2-)
unnamed: C12.1, U2.6 (V-)
unnamed: C7.2, R14.2
unnamed: CON11.4, U2.13 (R1IN)
unnamed: CON11.2, U2.14 (T1OUT)
unnamed: Q3.2 (B), R11.2
unnamed: CON6.2 (PM), Q1.1 (C)
unnamed: Q1.2 (B), R1.2
unnamed: CON5.2 (PM), Q2.1 (C)
unnamed: CON8.16 (LED-), R15.1
unnamed: C11.2, U2.2 (V+)
unnamed: Q2.2 (B), R6.2
unnamed: CON7.2 (PM), Q3.1 (C)

Notes on the sheet:
Drivers Leds
Antirrebotes
UART Biometricos
UART Comunicaciones
Interfase Micrófonos

Schematic: BBB.sch, Cape Beaglebone Black Bancas

Parts:
BG1: BEAGLEBONE_BLACK

Connections:
/Beaglebone Black/DC_3.3V: BG1.C3, BG1.C4; also elsewhere on the board
/Beaglebone Black/GPIO1_0: BG1.B26; also elsewhere on the board
/Beaglebone Black/GPIO1_1: BG1.B24; also elsewhere on the board
/Beaglebone Black/GPIO1_2: BG1.B5; also elsewhere on the board
/Beaglebone Black/GPIO1_4: BG1.B23; also elsewhere on the board
/Beaglebone Black/GPIO1_5: BG1.B22; also elsewhere on the board
/Beaglebone Black/GPIO1_6: BG1.B3; also elsewhere on the board
/Beaglebone Black/GPIO1_30: BG1.B21; also elsewhere on the board
/Beaglebone Black/GPIO1_31: BG1.B20; also elsewhere on the board
/Beaglebone Black/GPIO2_6: BG1.B45; also elsewhere on the board
/Beaglebone Black/GPIO2_7: BG1.B46; also elsewhere on the board
/Beaglebone Black/GPIO2_8: BG1.B43; also elsewhere on the board
/Beaglebone Black/GPIO2_9: BG1.B44; also elsewhere on the board
/Beaglebone Black/GPIO2_10: BG1.B41; also elsewhere on the board
/Beaglebone Black/GPIO2_11: BG1.B42; also elsewhere on the board
/Beaglebone Black/GPIO2_12: BG1.B39; also elsewhere on the board
/Beaglebone Black/UART1_RXD: BG1.C26; also elsewhere on the board
/Beaglebone Black/UART1_TXD: BG1.C24; also elsewhere on the board
/Beaglebone Black/UART2_RXD: BG1.C22; also elsewhere on the board
/Beaglebone Black/UART2_TXD: BG1.C21; also elsewhere on the board
/Beaglebone Black/VDD_5V: BG1.C5; also elsewhere on the board
GND: BG1.B1, BG1.B2, BG1.C1, BG1.C2, BG1.C43, BG1.C44, BG1.C46; also elsewhere on the board

Board: 2 copper layers, 85.0 x 69.4 mm, 55 parts (1 on the bottom side), 41 nets.

Other parts of the board:
PIN_ARRAY_1, PIN_ARRAY_1#2: Val**; PIN_ARRAY_1

Their connections:
/Tierra: PIN_ARRAY_1.1, PIN_ARRAY_1#2.1; also elsewhere on the board

## Commit log

2014-07-16 primer commit
2014-07-16 subo casi todo
2014-07-16 creacion carpeta sources
2014-07-22 nueva imagen
2014-07-22 imagen svg
2014-07-22 imagen svgplana
2014-07-23 descargada libreria para gpio
2014-07-29 lista de pines

Notices in the files:
diseñopcb/cape/BBB.sch:
GNU GPL
